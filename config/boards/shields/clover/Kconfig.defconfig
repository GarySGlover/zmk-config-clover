## config/boards/shields/clover/Kconfig.defconfig
```kconfig
if SHIELD_CLOVER

config ZMK_KEYBOARD_NAME
    default "clover"

config ZMK_USB
	default y

endif
```
